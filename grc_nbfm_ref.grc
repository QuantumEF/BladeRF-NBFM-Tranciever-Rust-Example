options:
  parameters:
    generate_options: qt_gui
    id: grc_nbfm_ref
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 44100*16
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1.0'
    max_dev: 2.5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/quantum_p/LocalDocs/bladerf-nbfm-transceiver/kn4vhm_test_mono_2.5k.wav
    repeat: 'True'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"bladerf=0,xb200=144M"'
    bb_gain0: '20'
    freq0: 147.555e6
    gain0: '10'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: '44100'
    type: float
  states: {}
- name: soapy_bladerf_sink_0
  id: soapy_bladerf_sink
  parameters:
    center_freq: 147.555e6
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}

connections:
- [analog_nbfm_tx_0, '0', osmosdr_sink_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_nbfm_tx_0, '0', soapy_bladerf_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
